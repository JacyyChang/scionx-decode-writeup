options:
  parameters:
    generate_options: qt_gui
    id: IQtoOgg_plot
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: n_capture
  id: variable
  parameters:
    comment: How many samples each Plot Capture block captures (30 s @ 100 kHz).
    value: 60*100000
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: variable_low_pass_filter_taps_0_2
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '15000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0_1_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 15.91*2
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Research\3_SCIONX GNURadio\1_Share\appendix_gnuradio\Data\20260720_220206_100000_98266_x.cs16
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0_2
    type: ccf
  states: {}
- name: plotcap_af
  id: plot_capture
  parameters:
    comment: Tap after the Quadrature Demod -- demodulated audio.
    mode: time,psd
    nfft: '1024'
    nsamples: n_capture
    out_dir: Figure
    prefix: demod
    samp_rate: samp_rate
    save_npy: 'False'
    skip: '0'
    sps: '0'
    title: ''
    type: float
  states: {state: disabled}
- name: plotcap_iq
  id: plot_capture
  parameters:
    comment: Tap after the Throttle -- raw IQ before the filter/demod chain.
    mode: spec
    nfft: '1024'
    nsamples: n_capture
    out_dir: Figure
    prefix: iq
    samp_rate: samp_rate
    save_npy: 'False'
    skip: '0'
    sps: '0'
    title: ''
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-40'
    type: complex
  states: {state: disabled}
- name: snippet_plot
  id: snippet
  parameters:
    code: |
      # NOTE: inside a Snippet the flowgraph object is bound to `self`,
      # not `tb` -- GRC generates `def snipfcn_<name>(self)`.
      # Safety net: flush whatever partial segment remains if the window gets
      # closed before the file runs out on its own (start_periodic_plot's
      # own stall-detection already handles the natural end-of-file case).
      self.plotcap_iq.stop_periodic_plot(flush_partial=True)
      # plotcap_af is currently disabled on the canvas -- calling a method on
      # a disabled block AttributeErrors, since GRC never instantiates it.
      # self.plotcap_af.stop_periodic_plot(flush_partial=True)
    section: main_after_stop
  states: {}
- name: snippet_start_periodic
  id: snippet
  parameters:
    code: |
      # NOTE: inside a Snippet the flowgraph object is bound to `self`,
      # not `tb` -- GRC generates `def snipfcn_<name>(self)`.
      # One PNG every 30s of newly-arrived IQ, until the file runs out.
      self.plotcap_iq.start_periodic_plot(30)
    section: main_after_start
  states: {}

connections:
- [analog_quadrature_demod_cf_0_1_0, '0', plotcap_af, '0']
- [analog_quadrature_demod_cf_0_1_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_1, '0']
- [blocks_throttle2_1, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_throttle2_1, '0', plotcap_iq, '0']
- [blocks_throttle2_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_1, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_quadrature_demod_cf_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
