options:
  parameters:
    author: SCIONX decode writeup
    description: Feed one known AX.25 frame into gr-satellites' HDLC Deframer twice -- serialized LSB-first and MSB-first -- and see which byte order it accepts.
    generate_options: no_gui
    id: hdlc_bitorder_test
    output_language: python
    run_options: run
    title: HDLC bit-order test (known frame -> HDLC Deframer -> Message Debug)
  states: {}

blocks:
- name: ax25_wire
  id: epy_module
  parameters:
    comment: Builds both candidate on-wire bit streams from the known 272-byte reference payload. Embedded here (rather than imported) so this .grc opens and runs anywhere with no sys.path setup. ax25_wire.py in this folder is the same code as a standalone, independently runnable script.
    source_code: |
      # Build the on-wire bit stream for a known AX.25/HDLC frame in
      # both possible byte-serialization orders. See ax25_wire.py (same folder)
      # for the fully commented standalone version of this code.

      REF = bytes.fromhex(
          "849c6086aa4060849c60a686b0e103f0"
          "007c083c81336a000201000000000020"
          "0000002b81336a000000000000030200"
          "0044090020100000c3add00099bf4e04"
          "8bc5780561d7f608d4a11f0000000000"
          "00000000000000000000000000000000"
          "00000000000000000000000000000000"
          "00000000000000000000000000000000"
          "00000000000000000000000000000000"
          "00000000000000000000000000000826"
          "08260826282620262000200020002000"
          "2000a03d78ff770f9bff8a1f161515e7"
          "b0b0b0b019181ae80c4002481b180000"
          "00000000000000000000000000000000"
          "00000000000000000000000000000000"
          "00000000000000000000000000000000"
          "00000000000000000000000000000000"
      )


      def crc16_x25(data):
          """CRC-16/X.25 (= HDLC FCS), same as scionx/hdlc.py."""
          crc = 0xFFFF
          for byte in bytes(data):
              crc ^= byte
              for _ in range(8):
                  crc = (crc >> 1) ^ 0x8408 if crc & 1 else crc >> 1
          return crc ^ 0xFFFF


      def serialize(data, lsb_first):
          """bytes -> unpacked bits. 0x7C becomes 00111110 (LSB-first, AX.25
          spec) or 01111100 (MSB-first)."""
          out = []
          for b in data:
              for k in (range(8) if lsb_first else range(7, -1, -1)):
                  out.append((b >> k) & 1)
          return out


      def bit_stuff(bits):
          """Insert a 0 after every five consecutive 1s (HDLC bit stuffing)."""
          out, ones = [], 0
          for b in bits:
              out.append(b)
              ones = ones + 1 if b == 1 else 0
              if ones == 5:
                  out.append(0)
                  ones = 0
          return out


      def build_wire(payload, lsb_first, n_flags=4):
          """flags + bit-stuffed(payload + FCS) + flags.

          0x7E is a bit-palindrome, so the flags look identical in both orders and
          the deframer finds frame boundaries either way -- only the body differs,
          so the FCS check is what actually discriminates the two orders."""
          fcs = crc16_x25(payload).to_bytes(2, "little")
          body = bit_stuff(serialize(payload + fcs, lsb_first))
          flag = [0, 1, 1, 1, 1, 1, 1, 0]
          return flag * n_flags + body + flag * n_flags


      WIRE_LSB = build_wire(REF, lsb_first=True)    # AX.25 spec order
      WIRE_MSB = build_wire(REF, lsb_first=False)   # the other order
  states: {}
- name: hdlc_deframer_lsb
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: hdlc_deframer_msb
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: message_debug_lsb
  id: blocks_message_debug
  parameters:
    comment: LSB-first branch output.
  states: {}
- name: message_debug_msb
  id: blocks_message_debug
  parameters:
    comment: 'MSB-first branch output (expected: stays silent).'
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'EXPECTED RESULT: the LSB-first branch prints one 272-byte PDU starting 84 9c 60 86 aa 40 ...; the MSB-first branch prints nothing at all, because its FCS check fails.'
  states: {}
- name: vector_source_lsb
  id: blocks_vector_source_x
  parameters:
    comment: Known frame, serialized LSB-first (what the AX.25 spec says).
    repeat: 'False'
    type: byte
    vector: ax25_wire.WIRE_LSB
  states: {}
- name: vector_source_msb
  id: blocks_vector_source_x
  parameters:
    comment: Exact same frame, serialized MSB-first instead.
    repeat: 'False'
    type: byte
    vector: ax25_wire.WIRE_MSB
  states: {}

connections:
- [hdlc_deframer_lsb, out, message_debug_lsb, print]
- [hdlc_deframer_msb, out, message_debug_msb, print]
- [vector_source_lsb, '0', hdlc_deframer_lsb, '0']
- [vector_source_msb, '0', hdlc_deframer_msb, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
